PACKAGECONFIG:append = " resolved"
RDEPENDS:${PN}:append = " wpa-supplicant"
